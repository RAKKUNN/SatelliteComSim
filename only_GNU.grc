options:
  parameters:
    author: vboxuser
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '1e6  '
    type: byte
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '12345'
    send_eof: 'False'
    type: byte
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    port: '50000'
    src_zeros: 'True'
    type: byte
  states: {}

connections:
- [blocks_throttle2_0, '0', network_udp_sink_0, '0']
- [network_udp_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
