options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '64'
    port: '12345'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    payloadsize: '64'
    port: '50000'
    src_zeros: 'False'
    type: complex
  states: {}

connections:
- [network_udp_source_0, '0', network_udp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
